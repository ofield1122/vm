# Keil uVision project FMC_MultiBoot.uvproj, settings and files
target FMC_MultiBoot (6160000::V6.16::ARMCLANG)
  device: NUC131SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x2000) IROM(0x00000000,0x11000) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC131\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC131.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC131/Source/: system_NUC131.c
    ../../../../Library/Device/Nuvoton/NUC131/Source/ARM/: startup_NUC131.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
target FMC_Boot0 (6160000::V6.16::ARMCLANG)
  device: NUC131SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_Boot0
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
target FMC_Boot1 (6160000::V6.16::ARMCLANG)
  device: NUC131SD2AE Nuvoton
  cpu: as above
  output: FMC_Boot1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
target FMC_Boot2 (6160000::V6.16::ARMCLANG)
  device: NUC131SD2AE Nuvoton
  cpu: as above
  output: FMC_Boot2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
target FMC_Boot3 (6160000::V6.16::ARMCLANG)
  device: NUC131SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x2000) IROM(0x00000000,0x11000)  CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
