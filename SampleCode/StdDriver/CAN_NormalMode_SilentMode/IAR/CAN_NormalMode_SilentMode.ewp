# IAR project CAN_NormalMode_SilentMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC131AE series Nuvoton NUC131AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC131\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CAN_NormalMode_SilentMode.bin
  ILINK.IlinkOutputFile: CAN_NormalMode_SilentMode.out
  ILINK.IlinkIcfFile: CAN_NormalMode_SilentMode.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/NUC131/Source/IAR/: startup_NUC131.s
    ../../../../Library/Device/Nuvoton/NUC131/Source/: system_NUC131.c
  group Library Files
    ../../../../Library/StdDriver/src/: adc.c can.c clk.c retarget.c sys.c uart.c
  group Source Files
    ../: main.c
