# Keil uVision project CAN_NormalMode_SilentMode.uvproj, settings and files
target CAN_NormalMode_SilentMode (6160000::V6.16::ARMCLANG)
  device: NUC131SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: CAN_NormalMode_SilentMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC131\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC131.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../Library/Device/Nuvoton/NUC131/Source/: system_NUC131.c
    ../../../../Library/Device/Nuvoton/NUC131/Source/ARM/: startup_NUC131.s
  group Source files
    ../: main.c
  group Library files
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c can.c
